# Keil uVision project MCU51.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: MCU51 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: beep.h beep.c comm.h comm.c digitalTube.h digitalTube.c keys.h keys.c lcd1602.h lcd1602.c led.h led.c timer.h timer.c uart.h uart.c log.h log.c IIC.h IIC.c DCMotor.h DCMotor.c AT24C02.h AT24C02.c OneWire.h OneWire.c DS18B20.h DS18B20.c relay.h relay.c testLed.c testKeys.c testTimer.c testDtube.c testLcd1602.c testUart.c testAT24C02.c testDS18B20.c testDCMotor.c testRelay.c DA_AD.h DA_AD.c testDA_AD.c interrupt.c interrupt.h testIR.c counter.c counter.h IR.c IR.h
